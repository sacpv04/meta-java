require openjdk-8-release.inc
